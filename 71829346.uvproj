# Keil uVision project 71829346.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 71829346 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\others
  group Source Group 1
    ./: main.c key.c test.c ultrasonic.c base.c
  group others
    ./others/: ds1302.c iic.c onewire.c
